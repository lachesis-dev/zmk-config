# Repository lachesis-dev/zmk-config

## KiCad design Cradle/KiCAD/Thorium改/Thorium34.kicad_pcb

Parts:
DA1, DA2, DA3, DA4, DA5, DA6, DA7, DA8, DA9, DA10, DA11, DA12, DA13, DA14, DA15, DA16, DA17: 1N4148W; D_SOD-123
DB1, DB2, DB3, DB4, DB5, DB6, DB7, DB8, DB9, DB10, DB11, DB12, DB13, DB14, DB15, DB16, DB17: 1N4148W; D_SOD-123
J1: Conn_01x04_Pin; Battery_SMD_2Pin_LiPoDirect
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17: ChocV1,2; ChocV1_V2_Hotswap_16mm_ReversibleSMD
SW18, SW19: SW_SPDT; SW_SPDT_Shouhan_MSK12C02
U2_R1, U3: XIAO-nRF52840-SMD; XIAO-nRF52840-SMD_SS

Connections:
/BAT+: SW18.3 (C), U3.32 (BAT)
/BAT+_R: SW19.3 (C), U2_R1.32 (BAT)
/COL0: SW1.1 (C), SW6.1 (C), SW11.1 (C), SW16.1 (C), U3.5 (P0.04_A4_D4_SDA)
/COL0_R: SW1.3 (C), SW6.3 (C), SW11.3 (C), SW16.3 (C), U2_R1.5 (P0.04_A4_D4_SDA)
/COL1: SW2.1 (C), SW7.1 (C), SW12.1 (C), SW17.1 (C), U3.6 (P0.05_A5_D5_SCL)
/COL1_R: SW2.3 (C), SW7.3 (C), SW12.3 (C), SW17.3 (C), U2_R1.6 (P0.05_A5_D5_SCL)
/COL2: SW3.1 (C), SW8.1 (C), SW13.1 (C), U3.7 (P1.11_D6_TX)
/COL2_R: SW3.3 (C), SW8.3 (C), SW13.3 (C), U2_R1.7 (P1.11_D6_TX)
/COL3: SW4.1 (C), SW9.1 (C), SW14.1 (C), U3.8 (P1.12_D7_RX)
/COL3_R: SW4.3 (C), SW9.3 (C), SW14.3 (C), U2_R1.8 (P1.12_D7_RX)
/COL4: SW5.1 (C), SW10.1 (C), SW15.1 (C), U3.9 (P1.13_D8_SCK)
/COL4_R: SW5.3 (C), SW10.3 (C), SW15.3 (C), U2_R1.9 (P1.13_D8_SCK)
/LeftLipo: J1.2, SW18.2 (B)
/ROW0: DA1.1 (K), DA2.1 (K), DA3.1 (K), DA4.1 (K), DA5.1 (K), U3.1 (P0.02_A0_D0)
/ROW0_R: DB1.1 (K), DB2.1 (K), DB3.1 (K), DB4.1 (K), DB5.1 (K), U2_R1.1 (P0.02_A0_D0)
/ROW1: DA6.1 (K), DA7.1 (K), DA8.1 (K), DA9.1 (K), DA10.1 (K), U3.2 (P0.03_A1_D1)
/ROW1_R: DB6.1 (K), DB7.1 (K), DB8.1 (K), DB9.1 (K), DB10.1 (K), U2_R1.2 (P0.03_A1_D1)
/ROW2: DA11.1 (K), DA12.1 (K), DA13.1 (K), DA14.1 (K), DA15.1 (K), U3.3 (P0.28_A2_D2)
/ROW2_R: DB11.1 (K), DB12.1 (K), DB13.1 (K), DB14.1 (K), DB15.1 (K), U2_R1.3 (P0.28_A2_D2)
/ROW3: DA16.1 (K), DA17.1 (K), U3.4 (P0.29_A3_D3)
/ROW3_R: DB16.1 (K), DB17.1 (K), U2_R1.4 (P0.29_A3_D3)
GND: J1.1, J1.3, U2_R1.33 (GND), U3.13 (GND), U3.33 (GND)
unnamed: DA1.2 (A), SW1.2 (D)
unnamed: DA2.2 (A), SW2.2 (D)
unnamed: DA3.2 (A), SW3.2 (D)
unnamed: DA4.2 (A), SW4.2 (D)
unnamed: DA5.2 (A), SW5.2 (D)
unnamed: DA6.2 (A), SW6.2 (D)
unnamed: DA7.2 (A), SW7.2 (D)
unnamed: DA8.2 (A), SW8.2 (D)
unnamed: DA9.2 (A), SW9.2 (D)
unnamed: DA10.2 (A), SW10.2 (D)
unnamed: DA11.2 (A), SW11.2 (D)
unnamed: DA12.2 (A), SW12.2 (D)
unnamed: DA13.2 (A), SW13.2 (D)
unnamed: DA14.2 (A), SW14.2 (D)
unnamed: DA15.2 (A), SW15.2 (D)
unnamed: DA16.2 (A), SW16.2 (D)
unnamed: DA17.2 (A), SW17.2 (D)
unnamed: DB1.2 (A), SW1.4 (D)
unnamed: DB2.2 (A), SW2.4 (D)
unnamed: DB3.2 (A), SW3.4 (D)
unnamed: DB4.2 (A), SW4.4 (D)
unnamed: DB5.2 (A), SW5.4 (D)
unnamed: DB6.2 (A), SW6.4 (D)
unnamed: DB7.2 (A), SW7.4 (D)
unnamed: DB8.2 (A), SW8.4 (D)
unnamed: DB9.2 (A), SW9.4 (D)
unnamed: DB10.2 (A), SW10.4 (D)
unnamed: DB11.2 (A), SW11.4 (D)
unnamed: DB12.2 (A), SW12.4 (D)
unnamed: DB13.2 (A), SW13.4 (D)
unnamed: DB14.2 (A), SW14.4 (D)
unnamed: DB15.2 (A), SW15.4 (D)
unnamed: DB16.2 (A), SW16.4 (D)
unnamed: DB17.2 (A), SW17.4 (D)
unnamed: J1.4, SW19.2 (B)

Notes on the sheet:
Thorium改 <両面基盤> A:Left B:Right

Board: 2 copper layers, 92.0 x 73.0 mm, 61 parts (20 on the bottom side), 57 nets.

Other parts of the board:
REB5: MountingHole_2.2mm_M2
REFB1, REFB2, REFB3, REFB4: MountingHole_2.2mm_M2
